# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ST; STM32F429xx; USE_OS_SYSTICK; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\..\..\generated\images\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\texts\include; ..\..\..\..\generated\gui_generated\include; ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\STM32F4xx_HAL_Driver; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\CMSIS; ..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\include; ..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\include\bsp; ..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\source\vendor\STM324x9I_EVAL; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os; ..\..\..\..\..\framework\touchgfx\platform\core\arm\cortex-m\CMSIS\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\src; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\mcu\stm32f4x9\inc; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: application-eval.srec
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkExtraOptions: --redirect _ZN8touchgfx12TextProvider10initializeEPKt9__va_list=_ZN8touchgfx12TextProvider10initializeEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringRTLERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZN8touchgfx7Unicode14formatToStringEPttPKt9__va_list=_ZN8touchgfx7Unicode14formatToStringEPttPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthLTREhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthLTREhPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthRTLEhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthRTLEhPKt8_VA_LIST
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_RobotoCondensed_Regular_114_4bpp.cpp FontGetters.cpp Kerning_RobotoCondensed_Regular_114_4bpp.cpp Table_RobotoCondensed_Regular_114_4bpp.cpp
  group Application/generated/images
    ../../../../generated/images/src/: bg.cpp BitmapDatabase.cpp counter_box.cpp down_btn.cpp down_btn_disabled.cpp down_btn_pressed.cpp up_btn.cpp up_btn_disabled.cpp up_btn_pressed.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/main_screen
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/main
    ../../../: main.cpp
  group CubeF4/Board
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_lcd.c stm324x9i_eval_nor.c stm324x9i_eval_sdram.c stm324x9i_eval_sram.c stm324x9i_eval_ts.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/stmpe811/: stmpe811.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/ts3510/: ts3510.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/exc7200/: exc7200.c
  group CubeF4/MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/IAR/: startup_stm32f429xx.s
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFXPort/Board
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/bsp/: STM324x9IButtonController.cpp STM324x9ITouchController.cpp
  group TouchGFXPort/MCU
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL.cpp
